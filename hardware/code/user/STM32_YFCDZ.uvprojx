# Keil uVision project STM32_YFCDZ.uvprojx, settings and files
target YFCDZ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_YFCDZ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\OLED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\SYSTEM\timer;..\SYSTEM\adc;..\SYSTEM\flash;..\HARDWARE\MODULES;..\SYSTEM\timer;..\SYSTEM\MYRTC;..\HARDWARE\ADXL345;..\HARDWARE\ALGORITHM;..\HARDWARE\DS18B20;..\HARDWARE\IIC;..\HARDWARE\MAX30102;..\HARDWARE\MYIIC;..\HARDWARE\MAX30102READ;..\HARDWARE\SHAKE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c main.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/MODULES/: Modules.c
    ../HARDWARE/ALGORITHM/: algorithm.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/MAX30102/: max30102.c
    ../HARDWARE/MAX30102READ/: max30102_read.c
    ../HARDWARE/MYIIC/: myiic.c
    ../HARDWARE/ADXL345/: adxl345.c
    ../HARDWARE/SHAKE/: shake.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/timer/: TIM2.c timer.c
    ../SYSTEM/adc/: adcx.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_i2c.c
  group README
    ./: readme.txt
